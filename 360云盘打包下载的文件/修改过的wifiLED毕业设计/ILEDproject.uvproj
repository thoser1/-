# Keil uVision project ILEDproject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ILEDproject +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Iled1.c stc12c5a60s2.h
